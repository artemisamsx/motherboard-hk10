# Repository artemisamsx/motherboard-hk10 (continued)

## KiCad design motherboard-hk10.kicad_pcb (continued)

Schematic: psg.kicad_sch

Parts:
C32, C33, C35: 10u; CP_Radial_D4.0mm_P2.00mm
C34, C36, C37: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
J6, J7: CONN_JOY; Joystick_conn
R3: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 2k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R8: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN4: 10K; R_Array_SIP9
RN5: 10K; R_Array_SIP5
U17: 74LS07; DIP-14_W7.62mm
U25: AY-3-8910; DIP-40_W15.24mm_Socket
U26, U27: 74HC157; DIP-16_W7.62mm

Connections:
/AUDIO: R3.2, R4.2, R5.2; also elsewhere on the board
/BEEP: C32.1; also elsewhere on the board
/CASIN: U25.14 (IOA7); also elsewhere on the board
/DATA0: U25.37 (DA0); also elsewhere on the board
/DATA1: U25.36 (DA1); also elsewhere on the board
/DATA2: U25.35 (DA2); also elsewhere on the board
/DATA3: U25.34 (DA3); also elsewhere on the board
/DATA4: U25.33 (DA4); also elsewhere on the board
/DATA5: U25.32 (DA5); also elsewhere on the board
/DATA6: U25.31 (DA6); also elsewhere on the board
/DATA7: U25.30 (DA7); also elsewhere on the board
/EXTSOUND: C33.1; also elsewhere on the board
/PSG/IOA0: U25.21 (IOA0), U26.4 (Y0)
/PSG/IOA1: U25.20 (IOA1), U26.7 (Y1)
/PSG/IOA2: U25.19 (IOA2), U26.9 (Y2)
/PSG/IOA3: U25.18 (IOA3), U26.12 (Y3)
/PSG/IOA4: U25.17 (IOA4), U27.4 (Y0)
/PSG/IOA5: U25.16 (IOA5), U27.7 (Y1)
/PSG/IOB0: U17.1, U25.13 (IOB0)
/PSG/IOB1: U17.3, U25.12 (IOB1)
/PSG/IOB2: U17.5, U25.11 (IOB2)
/PSG/IOB3: U17.9, U25.10 (IOB3)
/PSG/IOB4: J6.8, U25.9 (IOB4)
/PSG/IOB5: J7.8, U25.8 (IOB5)
/PSG/IOB6: U25.7 (IOB6), U26.1 (S), U27.1 (S)
/PSG/JOYA1: J6.1 (UP), RN4.9, U26.2 (A0)
/PSG/JOYA2: J6.2 (DOWN), RN4.8, U26.5 (A1)
/PSG/JOYA3: J6.3 (LEFT), RN4.7, U26.11 (A2)
/PSG/JOYA4: J6.4 (RIGHT), RN4.6, U26.14 (A3)
/PSG/JOYA6: J6.6 (TRIG1), RN5.5, U17.8, U27.2 (A0)
/PSG/JOYA7: J6.7 (TRIG2), RN5.4, U17.6, U27.5 (A1)
/PSG/JOYB1: J7.1 (UP), RN4.5, U26.3 (B0)
/PSG/JOYB2: J7.2 (DOWN), RN4.4, U26.6 (B1)
/PSG/JOYB3: J7.3 (LEFT), RN4.3, U26.10 (B2)
/PSG/JOYB4: J7.4 (RIGHT), RN4.2, U26.13 (B3)
/PSG/JOYB6: J7.6 (TRIG1), RN5.3, U17.4, U27.3 (B0)
/PSG/JOYB7: J7.7 (TRIG2), RN5.2, U17.2, U27.6 (B1)
/PSGBC1: U25.29 (BC1); also elsewhere on the board
/PSGBDIR: U25.27 (BDIR); also elsewhere on the board
/PSGCLK: U25.22 (CLK); also elsewhere on the board
/~KANALOCK: R7.1, U25.6 (IOB7); also elsewhere on the board
/~RESET: U25.23 (~RESET); also elsewhere on the board
GND: C34.2, C36.2, C37.2, J6.9 (GND), J7.9 (GND), R6.2, R7.2, U25.1 (GND), U25.24 (~A9), U26.8 (GND), U26.15 (~E), U27.8 (GND), U27.10 (B2), U27.11 (A2), U27.13 (B3), U27.14 (A3), U27.15 (~E); also elsewhere on the board
unnamed: C32.2, R3.1
unnamed: C33.2, R4.1
unnamed: C35.2, R5.1
unnamed: C35.1, R6.1, U25.3 (B), U25.4 (A), U25.38 (C)
unnamed: R8.2, U25.15 (IOA6)
VCC: C34.1, C36.1, C37.1, J6.5 (VCC), J7.5 (VCC), R8.1, RN4.1, RN5.1, U25.25 (A8), U25.28 (BC2), U25.40 (VCC), U26.16 (VCC), U27.16 (VCC); also elsewhere on the board

Notes on the sheet:
This just mixes the three sound sources into a single line without amplifying. This should provide a reasonably good gain for output. Otherwise, a LM386 amplifier IC should be used instead.

Schematic: cassette.kicad_sch

Parts:
C38, C42: 1uF; CP_Radial_D4.0mm_P2.00mm
C39, C41: 22nF; C_Disc_D3.0mm_W2.0mm_P2.50mm
C40: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
D2: 1N4448; D_DO-35_SOD27_P7.62mm_Horizontal
J8: DIN8
K1: Relay; Relay_SPDT_Omron-G5LE-1
Q1: 2N2907; TO92
R9: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10, R12, R14: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11: 2k2; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R15: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R16: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17, R18: 2k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U28: LM311; DIP-8_W7.62mm

Connections:
/CASIN: R9.1, U28.7 (COLOUT); also elsewhere on the board
/CASOUT: C38.1; also elsewhere on the board
/~CASMOTOR: R11.2; also elsewhere on the board
GND: C39.2, C40.2, C42.2, J8.1, J8.2, J8.3, J8.8, Q1.1 (1C), R13.1, R18.1, U28.1 (EMITOUT), U28.4 (GND); also elsewhere on the board
unnamed: C38.2, R10.2
unnamed: C39.1, R10.1, R12.2
unnamed: C41.1, R14.1
unnamed: C41.2, J8.5
unnamed: J8.4, R12.1, R13.2
unnamed: J8.6, K1.4
unnamed: J8.7, K1.3
unnamed: Q1.2 (B), R11.1
unnamed: D2.1, K1.2, Q1.3 (E)
unnamed: C42.1, R16.2, R17.1, R18.2, U28.2 (IN+)
unnamed: R14.2, R15.1, R16.1, U28.3 (IN-)
VCC: C40.1, D2.2, K1.1, R9.2, R15.2, R17.2, U28.8 (VCC); also elsewhere on the board

Notes on the sheet:
Cassette in (read)
Cassette out (write)
REM+
REM-

Schematic: clock.kicad_sch

Parts:
C19, C20: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
U6: 74HC08; DIP-14_W7.62mm
U8: 74HC74; DIP-14_W7.62mm
Y1: SG-531; Oscillator_SeikoEpson_SG-8002DC

Connections:
/CLK: U6.11, U8.3 (CP); also elsewhere on the board
/PSGCLK: U8.5 (Q); also elsewhere on the board
GND: C19.2, C20.2, U8.7 (GND), Y1.4 (GND); also elsewhere on the board
unnamed: U8.2 (D), U8.6 (~Q)
unnamed: U6.13, Y1.5 (OUT)
VCC: C19.1, C20.1, U6.12, U8.1 (~RD), U8.4 (~SD), U8.14 (VCC), Y1.1 (OE), Y1.8 (Vcc); also elsewhere on the board

Notes on the sheet:
Buffered clock signal using a spare 7408 AND-gate

Schematic: decoding.kicad_sch

Parts:
C1, C2, C3, C4, C5, C6: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
U1: 74HC04; DIP-14_W7.62mm
U2, U3, U4: 74HC32; DIP-14_W7.62mm
U5: 74HC139; DIP-16_W7.62mm
U6: 74HC08; DIP-14_W7.62mm
U7: 74HC138; DIP-16_W7.62mm
U8: 74HC74; DIP-14_W7.62mm

Connections:
/ADDR0: U3.9; also elsewhere on the board
/ADDR1: U1.3, U3.13; also elsewhere on the board
/ADDR3: U7.1 (A0); also elsewhere on the board
/ADDR4: U7.2 (A1); also elsewhere on the board
/ADDR5: U7.3 (A3); also elsewhere on the board
/ADDR6: U2.2; also elsewhere on the board
/ADDR7: U1.9; also elsewhere on the board
/ADDR14: U5.14 (A0); also elsewhere on the board
/ADDR15: U1.1, U3.2, U5.13 (A1); also elsewhere on the board
/DATADIR: U6.3; also elsewhere on the board
/DECODING/~PPISL: U4.5, U4.9, U7.10 (~Y5), U8.10 (~SD)
/DECODING/~PSGBDIR: U1.13, U3.11, U6.10
/DECODING/~PSGRD: U2.5, U2.8
/DECODING/~PSGSL: U2.10, U2.12, U7.11 (~Y4)
/DECODING/~PSGWR: U2.11, U3.12
/PSGBC1: U1.10; also elsewhere on the board
/PSGBDIR: U1.12; also elsewhere on the board
/~CS1: U5.11 (~Y1), U6.4; also elsewhere on the board
/~CS2: U5.10 (~Y2), U6.5; also elsewhere on the board
/~CS12: U6.6; also elsewhere on the board
/~IORQ: U4.1, U7.5 (~E2); also elsewhere on the board
/~M1: U4.2, U7.6 (E3); also elsewhere on the board
/~MREQ: U4.12; also elsewhere on the board
/~PPIRDY: U8.8 (~Q); also elsewhere on the board
/~PPIRD: U4.6; also elsewhere on the board
/~PPIWR: U4.8; also elsewhere on the board
/~RAMSL0: U3.6; also elsewhere on the board
/~RAMSL1: U3.3; also elsewhere on the board
/~RD: U2.9, U4.4, U5.15 (~OE), U6.1; also elsewhere on the board
/~RESET: U8.13 (~RD); also elsewhere on the board
/~RFSH: U1.5; also elsewhere on the board
/~SLTSL1: U3.1, U3.4; also elsewhere on the board
/~SLTSLEN: U4.11; also elsewhere on the board
/~VDPSL: U7.12 (~Y3); also elsewhere on the board
/~WR: U2.13, U4.10; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.7 (GND), U6.7 (GND), U7.8 (GND), U8.11 (CP), U8.12 (D); also elsewhere on the board
unnamed: U1.2, U3.5
unnamed: U1.4, U2.4
unnamed: U1.6, U4.13
unnamed: U1.8, U2.1
unnamed: U1.11, U3.8
unnamed: U2.6, U6.9
unnamed: U3.10, U6.8
unnamed: U4.3, U6.2
unnamed: U2.3, U7.4 (~E1)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, U1.14 (VCC), U2.14 (VCC), U3.14 (VCC), U4.14 (VCC), U6.14 (VCC), U7.16 (VCC); also elsewhere on the board

Board: 2 copper layers, 128 parts (0 on the bottom side), 203 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11: MountingHole_3.2mm_M3_DIN965_Pad
H12, H13, H14, H15, H16, H17: MountingHole_3.2mm_M3_DIN965

Notices in the files:
motherboard-hk10.kicad_pcb:
Copyright(C) 2018-2026 Alvaro Polo
